# Keil uVision project Car_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: Car_PSoC3lib (library)
  c flags: Optimize=2
  c define: DEBUG
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: DEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: CODE RU RC(10) IX CL(XDATA(X:0x0000-X:0x1FFF)) CL(CODE(C:0x0000-C:0xFFFF)) CL(CONST(C:0x0000-C:0xFFFF))
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h cydisabledsheets.h HE_ISR.c HE_ISR.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h LCD.c LCD.h LCD_PM.c LCD_LCDPort.c LCD_LCDPort.h LCD_LCDPort_aliases.h HE_IN_PIN.c HE_IN_PIN.h HE_IN_PIN_aliases.h PWM_OUT_PIN.c PWM_OUT_PIN.h PWM_OUT_PIN_aliases.h HE_TIMER.c HE_TIMER.h HE_TIMER_PM.c HE_TIMER_CLK.c HE_TIMER_CLK.h COM_SYNC_OUT_PIN.c COM_SYNC_OUT_PIN.h COM_SYNC_OUT_PIN_aliases.h VERT_SYNC_OUT_IN.c VERT_SYNC_OUT_IN.h VERT_SYNC_OUT_IN_aliases.h MOTOR_PWM.c MOTOR_PWM.h MOTOR_PWM_PM.c MOTOR_PWM_CLK.c MOTOR_PWM_CLK.h STEERING_PWM_OUT_PIN.c STEERING_PWM_OUT_PIN.h STEERING_PWM_OUT_PIN_aliases.h STEERING_PWM.c STEERING_PWM.h STEERING_PWM_PM.c STEERING_PWM_CLK.c STEERING_PWM_CLK.h VSYNC_ISR.c VSYNC_ISR.h COM_VID_IN_PIN.c COM_VID_IN_PIN.h COM_VID_IN_PIN_aliases.h Clock_1.c Clock_1.h VIDEO_OUT_COMPARE.c VIDEO_OUT_COMPARE.h VIDEO_OUT_COMPARE_PM.c CAM_LINECOUNTER_ISR.c CAM_LINECOUNTER_ISR.h CAM_LINEREAD_COUNTER.c CAM_LINEREAD_COUNTER.h CAM_LINEREAD_COUNTER_PM.c VDAC8_1.c VDAC8_1.h VDAC8_1_PM.c VIDEO_OUT_TIMER.c VIDEO_OUT_TIMER.h VIDEO_OUT_TIMER_PM.c read_camera_line_ISR.c read_camera_line_ISR.h
target Release (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: Car_PSoC3lib (library)
  c flags: Optimize=8
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: as above
